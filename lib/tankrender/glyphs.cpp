#include "glyphs.h"

namespace tank::render {

namespace {
struct Art {
  char ch;
  const char* rows;  // 7 rows of 5, '#' = on, separated by '|'
};

constexpr Art kArt[] = {
    {'>', "#....|.#...|..#..|...#.|..#..|.#...|#...."}, {'<', "....#|...#.|..#..|.#...|..#..|...#.|....#"},
    {'(', "...#.|..#..|.#...|.#...|.#...|..#..|...#."}, {')', ".#...|..#..|...#.|...#.|...#.|..#..|.#..."},
    {'\'', "..#..|..#..|.#...|.....|.....|.....|....."}, {'`', ".#...|..#..|...#.|.....|.....|.....|....."},
    {'/', ".....|....#|...#.|..#..|.#...|#....|....."}, {'\\', ".....|#....|.#...|..#..|...#.|....#|....."},
    {'|', "..#..|..#..|..#..|..#..|..#..|..#..|..#.."}, {'-', ".....|.....|.....|#####|.....|.....|....."},
    {'_', ".....|.....|.....|.....|.....|.....|#####"}, {'#', ".#.#.|.#.#.|#####|.#.#.|#####|.#.#.|.#.#."},
    {'%', "##...|##..#|...#.|..#..|.#...|#..##|...##"}, {':', ".....|.##..|.##..|.....|.##..|.##..|....."},
    {'"', ".#.#.|.#.#.|.#.#.|.....|.....|.....|....."}, {'*', ".....|..#..|#.#.#|.###.|#.#.#|..#..|....."},
    {'+', ".....|..#..|..#..|#####|..#..|..#..|....."}, {'.', ".....|.....|.....|.....|.....|.##..|.##.."},
    {',', ".....|.....|.....|.....|.##..|..#..|.#..."}, {'o', ".....|.....|.###.|#...#|#...#|#...#|.###."},
    {'~', ".....|.....|.#...|#.#.#|...#.|.....|....."}, {'@', ".###.|#...#|#.###|#.#.#|#.###|#....|.###."},
    {'Y', "#...#|#...#|.#.#.|..#..|..#..|..#..|..#.."}, {'{', "...##|..#..|..#..|.#...|..#..|..#..|...##"},
    {'}', "##...|..#..|..#..|...#.|..#..|..#..|##..."}, {'&', ".##..|#..#.|#.#..|.#...|#.#.#|#..#.|.##.#"},
};

struct Table {
  uint8_t rows[128][7]{};
  bool present[128]{};
  Table() {
    for (const Art& a : kArt) {
      const auto c = static_cast<unsigned char>(a.ch);
      int r = 0, col = 0;
      for (const char* p = a.rows; *p; ++p) {
        if (*p == '|') { ++r; col = 0; continue; }
        if (*p == '#') rows[c][r] = static_cast<uint8_t>(rows[c][r] | (16 >> col));
        ++col;
      }
      present[c] = true;
    }
  }
};
}  // namespace

const uint8_t* glyphRows(char ch) {
  static const Table table;  // built once, no heap
  const auto c = static_cast<unsigned char>(ch);
  return c < 128 && table.present[c] ? table.rows[c] : nullptr;
}

}  // namespace tank::render
